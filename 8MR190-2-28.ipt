# Autodesk Inventor part: 8MR190-2-28
## iProperties
Created: 2008-03
Part Number: 8MR190-2-28
Document SubType Name: Modeling
Designer: Darius
Author: Darius
## Feature names
1. Base1
